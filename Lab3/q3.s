	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=SRC1
	LDR R1,=SRC2
	LDR R5,=DIFF
	MOV R6,#4
	LDR R8,=BORROW
	
	LDR R2,[R0],#4
	LDR R3,[R1],#4
	SUBS R4,R2,R3
	STR R4,[R5],#4
	SUB R6,#1
	TEQ R6,#0
	BNE UP
UP
	LDR R2,[R0],#4
	LDR R3,[R1],#4
	SBCS R4,R2,R3
	STR R4,[R5],#4
	SUB R6,#1
	TEQ R6,#0
	BNE UP
	
	MOV R7,#0
	SBC R6,#0
	STRB R7,[R8]
STOP B STOP
SRC1 DCD 0X1,0X2,0X3,0X4 
SRC2 DCD 0X5,0X6,0X7,0X8
	AREA mydata,DATA,READWRITE
DIFF DCD 0,0,0,0
BORROW DCB 0
	END
	