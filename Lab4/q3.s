	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,= HEX
	LDR R0,[R0]
	MOV R3,#0
BACK BL DIVIDE
	CMP R0,#0
	BNE BACK
	
	LDR R4,=BCD
	STR R5,[R4]
STOP B STOP

DIVIDE MOV R2,#0
UP CMP R0,#0XA
	BLO EXIT
	SUB R0,#0XA
	ADD R2,#1
	B UP
	
EXIT LSL R0,R3
	ORR R5,R0
	ADD R3,#4
	MOV R0,R2
	BX LR
	
HEX DCD 0XA8
	AREA mydata,DATA,READWRITE
BCD DCD 0
	END
	